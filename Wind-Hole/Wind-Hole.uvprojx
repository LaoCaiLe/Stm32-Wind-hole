# Keil uVision project Wind-Hole.uvprojx, settings and files
target Wind-Hole (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Wind-Hole
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\.eide\deps;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\Include;.\.eide\deps\STM32F1xx_DFP\Startup;.\pack\Keil\STM32F1xx_DFP.2.3.0\Device\StdPeriph_Driver\inc;.\.eide\deps\STM32F1xx_DFP\StdPeriphDrivers.Framework;.\.eide\deps\STM32F1xx_DFP\StdPeriphDrivers.RCC;.\.eide\deps\STM32F1xx_DFP\StdPeriphDrivers.GPIO;.\src\User;.\src\SYSTEM\usart;.\src\SYSTEM\SysTick;.\src\SYSTEM\system;.\src\FWLIB\src;.\src\FWLIB\inc;.\src\CMSIS;.\src\APP
  asm define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  library: MicroLIB
  memory RVCT1: RAM 0x8000000 size 0x10000
  memory RVCT6: RAM 0x20000000 size 0x5000
  group SRC/USER
    ./src/User/: main.c stm32f10x_it.c system_stm32f10x.c
  group SRC/SYSTEM/USART
    ./src/SYSTEM/usart/: usart.c
  group SRC/SYSTEM/SYSTICK
    ./src/SYSTEM/SysTick/: SysTick.c
  group SRC/FWLIB/SRC
    ./src/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SRC/CMSIS
    ./src/CMSIS/: startup_stm32f10x_md.s
  group SRC/APP
    ./src/APP/: ANO_Data_Transfer.c input.c key.c led.c loop.c oled.c PidControl.c pwm.c SR05.c sys_time.c
